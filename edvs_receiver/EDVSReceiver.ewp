# IAR project EDVSReceiver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM320518_EVAL; STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\CMSIS\Device\ST\STM32F0xx\Include; Libraries\CMSIS\Include; Eval-Board; $PROJ_DIR$; src; include; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM0; Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; include
  OBJCOPY.OOCOutputFile: EDVSReceiver.bin
  ILINK.IlinkOutputFile: EDVSReceiver.out
  ILINK.IlinkIcfFile: linker\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Eval-Board
    Eval-Board/: stm320518_eval.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../FreeRTOS/portable/MemMang/: heap_2.c
    ../FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group include
    include/: dvs_usart.h FreeRTOSConfig.h pc_usart.h spinn_channel.h
  group Libraries/CMSIS
    Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Libraries/StdPeriph_Driver
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group src
    src/: dvs_usart.c main.c main_receiver.c pc_usart.c spinn_channel.c startup_stm32f0xx.s
  group Standard-Demo-Tasks
    Common/Minimal/: blocktim.c countsem.c dynamic.c recmutex.c
